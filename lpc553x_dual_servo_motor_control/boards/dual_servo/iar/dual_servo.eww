<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dual_servo.ewp</path>
    </project>
    <batchBuild />
</workspace>
