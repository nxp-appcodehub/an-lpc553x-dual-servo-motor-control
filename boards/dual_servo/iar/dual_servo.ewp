# IAR project dual_servo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S36 NXP LPC55S36
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S36JBD100; FRDM_LPC; RTCESL_PQ_ON=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\devices\LPC55S36\drivers; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\AMCLIB\Include; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR/GDFLIB/Include; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR/GFLIB/Include; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR/GMCLIB/Include; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR/MLIB/Include; ..\..\..\devices\LPC55S36; ..\..\..\devices\LPC55S36\utilities\str; ..\..\..\devices\LPC55S36\utilities\debug_console; ..\..\..\components\lists; ..\..\..\components\serial_manager; ..\..\..\components\uart; ..\..\..\middleware\freemaster\src\common; ..\..\..\middleware\freemaster\src\platforms\gen32le; ..\..\..\middleware\freemaster\src\drivers\mcuxsdk\can; ..\..\..\middleware\freemaster\src\drivers\mcuxsdk\serial; ..\..\..\CMSIS\Core\Include; ..\motor_control; ..\parameter; ..\mc_drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dual_servo.srec
  ILINK.IlinkOutputFile: dual_servo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x1000; __usb_use_usbram__=1
  ILINK.IlinkIcfFile: LPC55S36_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\AMCLIB\AMCLIB.a; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\GFLIB\GFLIB.a; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\GDFLIB\GDFLIB.a; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\GMCLIB\GMCLIB.a; ..\..\..\middleware\CM33F_RTCESL_4.6.2_IAR\MLIB\MLIB.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group board
    ../: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group CM33F_RTCESL_4.6.2_IAR/AMCLIB/Include
    ../../../middleware/CM33F_RTCESL_4.6.2_IAR/AMCLIB/Include/: amclib.h AMCLIB_ACIMCtrlMTPA_FLT.h AMCLIB_ACIMRotFluxObsrv_FLT.h AMCLIB_ACIMSpeedMRAS_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_CtrlFluxWkng_FLT.h amclib_FP.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvAB_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib_types.h
  group CM33F_RTCESL_4.6.2_IAR/GDFLIB/Include
    ../../../middleware/CM33F_RTCESL_4.6.2_IAR/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterExp_FLT.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR1_FLT.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR2_FLT.h GDFLIB_FilterIIR2PQ_FLT.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR3_FLT.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterIIR4_FLT.h GDFLIB_FilterMA_A32.h GDFLIB_FilterMA_FLT.h gdflib_FP.h gdflib_types.h
  group CM33F_RTCESL_4.6.2_IAR/GFLIB/Include
    ../../../middleware/CM33F_RTCESL_4.6.2_IAR/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Acos_FLT.h GFLIB_Asin_F16.h GFLIB_Asin_FLT.h GFLIB_Atan_F32.h GFLIB_Atan_FLT.h GFLIB_AtanYX_F16.h GFLIB_AtanYX_FLT.h GFLIB_AtanYXPQ_F16.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPDp_FLT.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlBetaIPp_FLT.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIDp_FLT.h GFLIB_CtrlPIp_A32.h GFLIB_CtrlPIp_FLT.h GFLIB_DFlexRamp_A32.h GFLIB_DFlexRamp_FLT.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_DRamp_FLT.h GFLIB_FlexRamp_A32.h GFLIB_FlexRamp_FLT.h GFLIB_FlexSRamp_A32.h GFLIB_FlexSRamp_FLT.h gflib_FP.h GFLIB_Hyst_F16_Asmi.h GFLIB_Hyst_FLT.h GFLIB_Integrator_A32.h GFLIB_Integrator_FLT.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_Limit_FLT.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_LowerLimit_FLT.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_Lut_FLT.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_LutPer_FLT.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Ramp_FLT.h GFLIB_SinCos_F32.h GFLIB_SinCos_FLT.h GFLIB_SinCosPQ_F32.h GFLIB_SinCosPQ_FLT.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_Sqrt_FLT_Asmi.h GFLIB_SqrtPQ_F16.h GFLIB_SqrtPQ_F32.h GFLIB_Tan_F32.h GFLIB_Tan_FLT.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_UpperLimit_FLT.h GFLIB_VectorLimit_F16.h GFLIB_VectorLimit_FLT.h
  group CM33F_RTCESL_4.6.2_IAR/GMCLIB/Include
    ../../../middleware/CM33F_RTCESL_4.6.2_IAR/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Clark_FLT.h GMCLIB_Decoupling_A32.h GMCLIB_Decoupling_FLT.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_ElimDcBusRip_FLT.h gmclib_FP.h GMCLIB_Park_F16_Asmi.h GMCLIB_Park_FLT.h GMCLIB_Svm_F16.h gmclib_types.h
  group CM33F_RTCESL_4.6.2_IAR/MLIB/Include
    ../../../middleware/CM33F_RTCESL_4.6.2_IAR/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Abs_FLT.h MLIB_Abs_FLT_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add4_FLT.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add_FLT.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Conv_FLT_Asmi.h MLIB_ConvSc_FLT_Asmi.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div_FLT.h mlib_FP.h MLIB_Log2_U16.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4_FLT.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asmi.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac_FLT.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_Mnac_FLT.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4_FLT.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_Msu_FLT.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_Mul_FLT.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Neg_FLT.h MLIB_PQ.h MLIB_Rcp1Q_A32.h MLIB_Rcp_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sign_FLT_Asmi.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub4_FLT.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub_FLT.h mlib_types.h RTCESL_cfg.h
  group CMSIS
    ../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/list
    ../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../devices/LPC55S36/: fsl_device_registers.h LPC55S36.h LPC55S36_features.h system_LPC55S36.c system_LPC55S36.h
  group drivers
    ../../../devices/LPC55S36/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_ctimer.c fsl_ctimer.h fsl_dac.c fsl_dac.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_lpadc.c fsl_lpadc.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group freemaster
    ../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_net.c freemaster_net.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers
    ../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
    ../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h
    ../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group motor_control
    ../motor_control/: M1_statemachine.c M1_statemachine.h M2_statemachine .c M2_statemachine.h motor_def.h motor_structure.c motor_structure.h register_types.h state_machine.c state_machine.h
  group motor_control/mc_driver
    ../mc_drivers/: mcdrv_adc_lpc55s36.c mcdrv_adc_lpc55s36.h mcdrv_eflexpwm_lpc.c mcdrv_eflexpwm_lpc.h mcdrv_enc_lpc55s36.c mcdrv_enc_lpc55s36.h
  group motor_control/parameter
    ../parameter/: M1_Params.h M2_Params.h trigonometric.h
  group source
    ../: char_pwrstg.h freemaster_cfg.h main.c mc_periph_init.c mc_periph_init.h
  group startup
    ../../../devices/LPC55S36/iar/: startup_LPC55S36.s
  group utilities
    ../../../devices/LPC55S36/utilities/: fsl_assert.c
    ../../../devices/LPC55S36/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../devices/LPC55S36/utilities/str/: fsl_str.c fsl_str.h
